<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\4.09.2024.ewp</path>
    </project>
    <batchBuild />
</workspace>
